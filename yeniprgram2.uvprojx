# Keil uVision project yeniprgram2.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: STM32F410RBTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: yeniprgram2
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: delay.c delay.h i2c.c i2c.h lcd.c lcd.h main.c modbus_rtu.c modbus_rtu.h pwm.cpp pwm.h sht3x.c sht3x.h sysclock.c sysclock.h uart.c uart.h interrupts.c filter.c filter.h adc.c adc.h error_check.c error_check.h sensor_task.c sensor_task.h watchdog.c watchdog.h flash_write.c Config_Manager.h Config_Manager.c appcons.h apptdef.h
software components: CMSIS:CORE 5.2.0, Device:Startup 2.6.3
